# Keil uVision project demasha3_stc.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G2K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 4ChanleControlBoard +hex
  c include: ..\Src;.\LCD
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c stc8a_it.c uarttask.c eeprom.c spi_flash.c ABencoder.c SaveConfigFile.c uuid.c
    ./LCD/: LCD.c
